# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS\Include;.\ek-tm4c123gxl
  asm define: Stack_Size=1024,Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c support.h RTOS_Kernel.c RTOS_Kernel.h RTOS_Kernel_cfg.h under_the_hood.c under_the_hood.h under_the_hood_cfg.h
  group CMSIS
    ./CMSIS/Include/: core_cm4.h
  group New Group
    ./ek-tm4c123gxl/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h
    ./ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
